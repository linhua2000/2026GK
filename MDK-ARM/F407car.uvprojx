# Keil uVision project F407car.uvprojx, settings and files
target F407car (6070000::V6.7::.\ARMCLANG)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x807FFFF)  CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: F407car +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F407xx
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../Middle_Drivers;../Middle_Drivers/LED;../Middle_Drivers/uart1;../Middle_Drivers/encoder;../app;../Middle_Drivers/motor;../Middle_Drivers/JY61P;../Middle_Drivers/mailuncontrol;../Middle_Drivers/kinematics;../SCSLib;../Middle_Drivers/receive;../Middle_Drivers/OLED;../Middle_Drivers/PID;../Middle_Drivers/odometry;..\Middle_Drivers\key
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c adc.c can.c i2c.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_ll_adc.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_can.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Middle_Drivers
    ../Middle_Drivers/LED/: led.c led.h
    ../Middle_Drivers/uart1/: uart1.c
    ../Middle_Drivers/encoder/: encoder.c
    ../Middle_Drivers/motor/: motor.c
    ../Middle_Drivers/mailuncontrol/: mailuncontrol.c
    ../Middle_Drivers/JY61P/: jy61p.c
    ../Middle_Drivers/kinematics/: kinematics.c
    ../Middle_Drivers/odometry/: odometry.c
    ../Middle_Drivers/receive/: receive.c receive.h
    ../Middle_Drivers/OLED/: OLED.c OLED.h OLED_Data.c OLED_Data.h oled_ui.c oled_ui.h
    ../Middle_Drivers/PID/: PID.c PID.h
    ../Middle_Drivers/key/: Key.c
  group app
    ../app/: control.c
  group SCSLib
    ../SCSLib/: INST.h SCS.c SCS.h SCServo.c SCServo.h SMS_STS.c SMS_STS.h uart.c uart.h
